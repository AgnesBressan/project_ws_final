Commit message: Adicionando pista - seguidor de linha

File: project_ws/urdf/description.urdf (robot description, URDF)
Before this commit: robot description, 6 links, 5 joints
Links:
- removed link camera_link
Joints:
- removed joint joint_base_to_camera_link
